# Keil uVision project STM32G030F6P6.uvprojx, settings and files
target DigitalClocks (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32G030F6P6
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Source;.\Source\Phy;.\Source\DS3231
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Device
    ./Source/: button.cpp buzzer.cpp device.cpp event_handler.cpp event_manager.cpp main.cpp display_segment.cpp parameters.cpp fsm.cpp
  group Periphery
    ./Source/Phy/: periphery.cpp ADC.cpp FLASH.cpp GPIO.cpp I2C1.cpp interrupts.cpp TICK.cpp TIM_SYSTEM.cpp TIM1.cpp TIM3.cpp TIM14.cpp TIM16.cpp TIM17.cpp WDT.cpp SPI1.cpp DMA_TIM1.cpp
  group DS3231
    ./Source/DS3231/: DS3231.cpp DS3231.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.4.0
